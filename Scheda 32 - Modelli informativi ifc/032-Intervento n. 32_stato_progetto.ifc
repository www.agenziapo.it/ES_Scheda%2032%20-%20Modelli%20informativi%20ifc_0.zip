Properties of the parts of a building model (IFC4X1)

# File
Time: 2024-03-06T14:19:03
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuilding (9)
Description: Created by Civil Site Design
Name
Pavement
Grass
Batter
NONE
2 x Sommità pennello esistente-Offset (1.000) pennello progetto/REB/RBAT/1/Massi
Sommità pennello esistente-Offset (1.000) pennello progetto/LEB/LBAT/1/Massi
2 x RBAT_4_Sommità pennello esistente-Offset (1.000) pennello progetto/C.L./REB/1/Massi

# IfcBuildingElementProxy (9)
Description: Created by Civil Site Design
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
Pavement | Pavement
Grass | Grass
Batter | Batter
NONE | NONE
2 x Sommità pennello esistente-Offset (1.000) pennello progetto/REB/RBAT/1/Massi | Sommità pennello esistente-Offset (1.000) pennello progetto/REB/RBAT/1/Massi | Sommità pennello esistente-Offset (1.000) pennello progetto | REB | RBAT | 1 | Massi
Sommità pennello esistente-Offset (1.000) pennello progetto/LEB/LBAT/1/Massi | Sommità pennello esistente-Offset (1.000) pennello progetto/LEB/LBAT/1/Massi | Sommità pennello esistente-Offset (1.000) pennello progetto | LEB | LBAT | 1 | Massi
2 x RBAT_4_Sommità pennello esistente-Offset (1.000) pennello progetto/C.L./REB/1/Massi | RBAT_4_Sommità pennello esistente-Offset (1.000) pennello progetto/C.L./REB/1/Massi | RBAT_4_Sommità pennello esistente-Offset (1.000) pennello progetto | C.L. | REB | 1 | Massi
